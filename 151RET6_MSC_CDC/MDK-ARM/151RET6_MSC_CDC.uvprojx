# Keil uVision project 151RET6_MSC_CDC.uvprojx, settings and files
target 151RET6_MSC_CDC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 151RET6_MSC_CDC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L151xE
  c include: ../Core/Inc; ../FATFS/Target; ../FATFS/App; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\..\MSC_CDC; ..\..\STM32_SPI_SD;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l151xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c spi.c tim.c stm32l1xx_it.c stm32l1xx_hal_msp.c stm32l1xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_ll_usb.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group SPI_SD
    ../../STM32_SPI_SD/: mmc_stm32l1_spi.c
  group USB_COMPOSITE
    ../../MSC_CDC/: usbd_cdc.c usbd_composite.c usbd_cdc_if.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
